# Keil uVision project ZEUS-v3.1.uvprojx, settings and files
target defaultConfig (6240000::V6.24::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZEUS-v3.1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c i2c.c lcd.c delay.c watchDogTimer.c relay.c timer.c soilSensor.c buttons.c
  group lib
    ./: i2c.h lcd.h delay.h watchDogTimer.h relay.h timer.h soilSensor.h buttons.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
